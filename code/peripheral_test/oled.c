/* SH1107 128x128 OLED over I2C, page addressing, text rows and bar graph. */
#include "oled.h"
#include "i2c.h"
#include "timebase.h"

/* ---- panel options (override with -D on the compiler command line) ---- */
#ifndef OLED_ADDR
#define OLED_ADDR       0x3C    /* 7-bit I2C address (some modules use 0x3D) */
#endif
#ifndef OLED_DCDC_CMD
#define OLED_DCDC_CMD   0x8A    /* DC-DC setting byte; try 0x8B if the panel stays dark */
#endif
#ifndef OLED_SEG_REMAP
#define OLED_SEG_REMAP  0xA0    /* 0xA1 mirrors the image horizontally */
#endif
#ifndef OLED_COM_SCAN
#define OLED_COM_SCAN   0xC0    /* 0xC8 flips the image vertically */
#endif

/* 5x7 font, ASCII 0x20..0x5A, one byte per column, bit0 = top row. */
static const uint8_t font5x7[59 * 5] = {
    0x00,0x00,0x00,0x00,0x00, 0x00,0x00,0x5F,0x00,0x00, 0x00,0x07,0x00,0x07,0x00, 0x14,0x7F,0x14,0x7F,0x14,
    0x24,0x2A,0x7F,0x2A,0x12, 0x23,0x13,0x08,0x64,0x62, 0x36,0x49,0x56,0x20,0x50, 0x00,0x08,0x07,0x03,0x00,
    0x00,0x1C,0x22,0x41,0x00, 0x00,0x41,0x22,0x1C,0x00, 0x2A,0x1C,0x7F,0x1C,0x2A, 0x08,0x08,0x3E,0x08,0x08,
    0x00,0x80,0x70,0x30,0x00, 0x08,0x08,0x08,0x08,0x08, 0x00,0x00,0x60,0x60,0x00, 0x20,0x10,0x08,0x04,0x02,
    0x3E,0x51,0x49,0x45,0x3E, 0x00,0x42,0x7F,0x40,0x00, 0x42,0x61,0x51,0x49,0x46, 0x21,0x41,0x45,0x4B,0x31,
    0x18,0x14,0x12,0x7F,0x10, 0x27,0x45,0x45,0x45,0x39, 0x3C,0x4A,0x49,0x49,0x30, 0x01,0x71,0x09,0x05,0x03,
    0x36,0x49,0x49,0x49,0x36, 0x06,0x49,0x49,0x29,0x1E, 0x00,0x36,0x36,0x00,0x00, 0x00,0x56,0x36,0x00,0x00,
    0x08,0x14,0x22,0x41,0x00, 0x14,0x14,0x14,0x14,0x14, 0x00,0x41,0x22,0x14,0x08, 0x02,0x01,0x51,0x09,0x06,
    0x32,0x49,0x79,0x41,0x3E,
    /* A-Z */
    0x7E,0x11,0x11,0x11,0x7E, 0x7F,0x49,0x49,0x49,0x36, 0x3E,0x41,0x41,0x41,0x22, 0x7F,0x41,0x41,0x22,0x1C,
    0x7F,0x49,0x49,0x49,0x41, 0x7F,0x09,0x09,0x09,0x01, 0x3E,0x41,0x49,0x49,0x7A, 0x7F,0x08,0x08,0x08,0x7F,
    0x00,0x41,0x7F,0x41,0x00, 0x20,0x40,0x41,0x3F,0x01, 0x7F,0x08,0x14,0x22,0x41, 0x7F,0x40,0x40,0x40,0x40,
    0x7F,0x02,0x0C,0x02,0x7F, 0x7F,0x04,0x08,0x10,0x7F, 0x3E,0x41,0x41,0x41,0x3E, 0x7F,0x09,0x09,0x09,0x06,
    0x3E,0x41,0x51,0x21,0x5E, 0x7F,0x09,0x19,0x29,0x46, 0x46,0x49,0x49,0x49,0x31, 0x01,0x01,0x7F,0x01,0x01,
    0x3F,0x40,0x40,0x40,0x3F, 0x1F,0x20,0x40,0x20,0x1F, 0x3F,0x40,0x38,0x40,0x3F, 0x63,0x14,0x08,0x14,0x63,
    0x07,0x08,0x70,0x08,0x07, 0x61,0x51,0x49,0x45,0x43
};

static char    g_shadow[OLED_ROWS][OLED_COLS];   /* what is currently on screen */
static uint8_t g_bar_last = 0xFF;

/* ---- low level: command / data transfers ---- */
static int begin(uint8_t control)               /* 0x00 = commands, 0x40 = data */
{
    return i2c_start_write(OLED_ADDR) && i2c_put(control);
}

static int send_cmds(const uint8_t *c, unsigned n)
{
    if (!begin(0x00)) return 0;
    for (unsigned i = 0; i < n; i++) {
        if (!i2c_put(c[i])) return 0;
    }
    return i2c_stop();
}

static int goto_row(unsigned row)
{
    uint8_t c[3] = { (uint8_t)(0xB0u | row), 0x00, 0x10 };   /* page, column 0 */
    return send_cmds(c, 3);
}

static const uint8_t *glyph(char ch)
{
    if (ch >= 'a' && ch <= 'z') ch = (char)(ch - 'a' + 'A');
    if (ch < 0x20 || ch > 0x5A) ch = ' ';
    return &font5x7[(unsigned)(ch - 0x20) * 5u];
}


int oled_text(unsigned row, const char *s)
{
    char buf[OLED_COLS];
    int same = 1;

    if (row >= OLED_ROWS) return 0;
    for (unsigned i = 0; i < OLED_COLS; i++) {
        char ch = *s ? *s++ : ' ';
        buf[i] = ch;
        if (ch != g_shadow[row][i]) same = 0;
    }
    if (same) return 1;

    if (!goto_row(row) || !begin(0x40)) return 0;
    for (unsigned i = 0; i < OLED_COLS; i++) {
        const uint8_t *g = glyph(buf[i]);
        for (unsigned k = 0; k < 5; k++) {
            if (!i2c_put(g[k])) return 0;
        }
        if (!i2c_put(0x00)) return 0;                        /* 1 px gap */
    }
    if (!i2c_put(0x00) || !i2c_put(0x00)) return 0;          /* pad 126 -> 128 columns */
    if (!i2c_stop()) return 0;

    for (unsigned i = 0; i < OLED_COLS; i++) g_shadow[row][i] = buf[i];
    return 1;
}

int oled_bar(unsigned row, uint8_t fill)
{
    if (row >= OLED_ROWS) return 0;
    if (fill > OLED_BAR_MAX) fill = OLED_BAR_MAX;
    if (fill == g_bar_last) return 1;

    if (!goto_row(row) || !begin(0x40)) return 0;
    for (unsigned col = 0; col < 128u; col++) {
        uint8_t b;
        if (col == 0 || col == 127u) b = 0xFF;
        else if (col <= fill)        b = 0x7E;
        else                         b = 0x42;
        if (!i2c_put(b)) return 0;
    }
    if (!i2c_stop()) return 0;
    g_bar_last = fill;
    return 1;
}

int oled_init(void)
{
    static const uint8_t init[] = {
        0xAE,                   /* display off */
        0xD5, 0x51,             /* clock divide / oscillator */
        0x20,                   /* page addressing mode */
        0x81, 0x4F,             /* contrast */
        0xAD, OLED_DCDC_CMD,    /* DC-DC setting */
        OLED_SEG_REMAP,
        OLED_COM_SCAN,
        0xDC, 0x00,             /* display start line */
        0xD3, 0x00,             /* display offset */
        0xA8, 0x7F,             /* multiplex ratio: 128 rows */
        0xD9, 0x22,             /* pre-charge */
        0xDB, 0x35,             /* VCOM deselect */
        0xA4,                   /* follow RAM content */
        0xA6                    /* normal (not inverted) */
    };
    static const uint8_t on = 0xAF;

    for (unsigned r = 0; r < OLED_ROWS; r++)
        for (unsigned c = 0; c < OLED_COLS; c++) g_shadow[r][c] = 0;   /* force full redraw */
    g_bar_last = 0xFF;

    if (!send_cmds(init, sizeof init)) return 0;
    for (unsigned r = 0; r < OLED_ROWS; r++)
        if (!oled_text(r, "")) return 0;        /* clear screen */
    delay_ms(100);
    return send_cmds(&on, 1);                   /* display on */
}
